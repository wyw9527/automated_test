# IAR project Project.ewp, settings and files
configuration GD32F30X_CL (ARM, debug)
  General.OGChipSelectEditMenu: GD32F305xE GD GD32F305xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL
  ICCARM.CCIncludePath2: ..\App; ..\GD32\inc; ..\GD32; ..\module; ..\RTT; ..\RTT\include\libc; ..\RTT\include; ..\RTT\components\finsh; ..\Cmp; ..\Bsp; ..\Drv; ..\SEGGER_RTT; ..\Ethernet\Internet; ..\Ethernet\W5500; ..\RyonJSON
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ASE_7000_1.02_20240425.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: GD32F305xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F30X_XD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F303xG GD GD32F303xG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_XD
  ICCARM.CCIncludePath2: ..\..\Firmware; ..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\Utilities; ..
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xG.icf
configuration GD32F30X_HD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\Utilities; ..
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xC.icf
  group (top)
    ../: 修改记录.txt
  group App
    ../App/: app_config.c app_server.c app_system.c
  group Bsp
    ../Bsp/: board.c bsp.c bsp_adc.c bsp_can.c bsp_io.c bsp_pmu.c bsp_pwm.c bsp_rtc.c bsp_spi.c bsp_uart.c
  group Cmp
    ../Cmp/: cmp.c cmp_ble.c cmp_load.c cmp_power.c cmp_prot_mt.c cmp_prot_upper.c cmp_w5500.c
  group Drv
    ../Drv/: drv.c drv_analog.c drv_clock.c drv_dido.c drv_flash.c drv_led.c drv_load_485.c drv_load_can.c drv_m8209.c drv_meter.c drv_power_box.c drv_pwm_cp.c drv_relay.c drv_serial.c
  group Ethernet
    ../Ethernet/Internet/: dhcp.c
    ../Ethernet/W5500/: socket.c utility.c w5500.c w5500_conf.c
  group GD
    ../GD32/: startup_gd32f30x_cl.s system_gd32f30x.c
  group GD/inc
    ../GD32/inc/: gd32f30x_adc.h gd32f30x_bkp.h gd32f30x_can.h gd32f30x_crc.h gd32f30x_ctc.h gd32f30x_dac.h gd32f30x_dbg.h gd32f30x_dma.h gd32f30x_enet.h gd32f30x_exmc.h gd32f30x_exti.h gd32f30x_fmc.h gd32f30x_fwdgt.h gd32f30x_gpio.h gd32f30x_i2c.h gd32f30x_misc.h gd32f30x_pmu.h gd32f30x_rcu.h gd32f30x_rtc.h gd32f30x_sdio.h gd32f30x_spi.h gd32f30x_timer.h gd32f30x_usart.h gd32f30x_wwdgt.h
  group GD/src
    ../GD32/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group RTT
    ../RTT/: board.c
    ../RTT/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group RTT/components/finsh
    ../RTT/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group RTT/src
    ../RTT/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RyonJSON
    ../RyonJSON/: RyanJson.c RyJsonAPI.c
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
